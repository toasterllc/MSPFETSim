# IAR project eZ-FET_Hil.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: uController_nguif; HAL_STREAM; eZ_FET
  ICC430.newCCIncludePaths: include; src\hil; src\hil\ez_fet; src\hil\fet_generic; src\fw; src\fw\fet; src\hal
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetHil
  XLINK.XclFile: config\Hil_lnk430F5528 .xcl
  XLINK.XlinkStackSize: 1
  group (top)
    $EW_DIR$/430/inc/: cfi.m43
    src/hil/ez_fet/: cstartup_hil.s43
  group config
    config/: Hil_lnk430F5528 .xcl
  group Hil
    src/hil/ez_fet/: arch.h hil.c hilDelays.c hilDelays.h
    src/hil/fet_generic/: hil_2wDma.c
