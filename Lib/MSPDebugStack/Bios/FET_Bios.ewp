# IAR project FET_Bios.ewp, settings and files
configuration eZ_FET_DCDC_Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: eZ_FET
  ICC430.newCCIncludePaths: include; src\fw; src\fw\fet; src\fw\fet\USB_config; src\fw\fet\F5xx_F6xx_Core_Lib; src\fw\; src\fw\fet\Fetinit; src\hil; src\dcdc; src\fw\fet\FetIcc
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetCore
  XLINK.XclFile: config\Bios_lnk430F5528.xcl
  XLINK.XlinkStackSize: 1
configuration MSP_FET_Debug (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  ICC430.CCDefines: MSP_FET
  ICC430.newCCIncludePaths: include; src\fw; src\fw\fet; src\fw\fet\USB_config; src\fw\fet\F5xx_F6xx_Core_Lib; src\fw\fet\Fetinit; src\hil; src\dcdc; src\fw\fet\FetIcc
  ICC430.CCOptLevel: 2
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetCore
  XLINK.XclFile: config\Bios_lnk430F6638.xcl
  group (top)
    src/fw/fet/Fet_cStartUp/: cstartup.s43
    src/fw/fet/: cstartup_Hal.s43 main.c
  group Bios
    src/fw/fet/: bios.c stream.c v3_0p.c v3_0p_hw_fet.c
  group config
    config/: Bios_lnk430F5528.xcl Bios_lnk430F6638.xcl
  group FetIcc
    src/fw/fet/FetIcc/: eZ_FET_IccMonitor.c MSP_FET_IccMonitor.c
  group FetInit
    src/fw/fet/FetInit/: eZ_FET_init.c Fet_initClock.c MSP_FET_init.c
  group USB
    src/fw/fet/: FetUsb.h usbConstructs.c usbConstructs.h usbEventHandling.c usbMain.c
  group USB/F5xx_F6xx_Core_Lib
    src/fw/fet/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group USB/USB_Common
    src/fw/fet/USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB/USB_Common/USB_API/USB_CDC_API
    src/fw/fet/USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB/USB_config
    src/fw/fet/USB_config/: descriptors.c descriptors.h UsbIsr.c
