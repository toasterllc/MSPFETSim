# IAR project FET_Hal.ewp, settings and files
configuration MSP_FET_Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: uController_nguif; HAL_STREAM; MSP_FET; ARCH_MSP432
  ICC430.newCCIncludePaths: include; src\hil; src\hil\ez_fet; src\fw; src\fw\fet; src\hal
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetHal
  XLINK.XclFile: config\hal_lnk430F6638.xcl
  XLINK.XlinkStackSize: 1
configuration eZ_FET_Debug (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  ICC430.CCDefines: uController_nguif; HAL_STREAM; eZ_FET
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetHal
  XLINK.XclFile: config\hal_lnk430F5528.xcl
  group (top)
    src/fw/fet/: cstartup_Hal.s43
  group Config
    config/: hal_lnk430F5528.xcl hal_lnk430F6638.xcl
  group Hal
    src/hil/: edt.c
    src/fw/fet/: hal.c HalGlobalVars.c halMain.c
  group Hal/MSP430
    src/hal/macros/: BitSequence.c BlowFuse.c Configure.c EemDataExchange.c EemDataExchangeAFE2xx.c ExecuteFunclet.c ExecuteFuncletJtag.c GetDcoFrequency.c GetDeviceIdPtr.c GetInterfaceMode.c GetJtagId.c GetNumOfDevices.c HilCommand.c IsJtagFuseBlown.c MagicPattern.c PollJStateReg430I.c Psa.c ReadAllCpuRegs.c ReadMemBytes.c ReadMemQuick.c ReadMemWords.c Reset430I.c RestoreContext_ReleaseJtag.c SetChainConfiguration.c SetDeviceChainInfo.c SingleStep.c StartJtag.c StartJtagActivationCode.c StopJtag.c SyncJtag_AssertPor_SaveContext.c SyncJtag_Conditional_SaveContext.c UnlockC092.c WaitForEem.c WaitForStorage.c WriteAllCpuRegs.c WriteMemBytes.c WriteMemWords.c
  group Hal/MSP430X
    src/hal/macros/: EemDataExchangeX.c ExecuteFuncletX.c PsaX.c ReadAllCpuRegsX.c ReadMemBytesX.c ReadMemQuickX.c ReadMemWordsX.c RestoreContext_ReleaseJtagX.c SingleStepX.c SyncJtag_AssertPor_SaveContextX.c SyncJtag_Conditional_SaveContextX.c WaitForStorageX.c WriteAllCpuRegsX.c WriteMemBytesX.c WriteMemWordsX.c
  group Hal/MSP430Xv2
    src/hal/macros/: BlowFuseFram.c BlowFuseXv2.c EemDataExchangeXv2.c ExecuteFuncletXv2.c LeaSyncConditional.c PollJStateReg.c PollJStateRegFR57xx.c PsaXv2.c ReadAllCpuRegsXv2.c ReadMemBytesXv2.c ReadMemQuickXv2.c ReadMemWordsXv2.c ResetXv2.c RestoreContext_ReleaseJtagXv2.c SendJtagMailboxXv2.c SingleStepJState.c SingleStepXv2.c SyncJtag_AssertPor_SaveContextXv2.c SyncJtag_Conditional_SaveContextXv2.c UnlockDeviceXv2.c UssSyncConditional.c WriteAllCpuRegsXv2.c WriteFramQuickXv2.c WriteMemBytesXv2.c WriteMemWordsXv2.c
  group Hal/MSP432
    src/hal/macros/: DisableDebugArm.c EnableDebugArm.c GetCpuIdArm.c GetInterfaceModeArm.c GetJtagIdCodeArm.c HaltArm.c MemApTransactionArm.c ReadAllCpuRegsArm.c ResetArm.c RunArm.c ScanApArm.c SingleStepArm.c WaitForDebugHaltArm.c WriteAllCpuRegsArm.c
