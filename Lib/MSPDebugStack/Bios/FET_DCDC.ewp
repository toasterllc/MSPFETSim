# IAR project FET_DCDC.ewp, settings and files
configuration MSP_FET_Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP_FET
  ICC430.newCCIncludePaths: include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetDcdc
  XLINK.XclFile: config\Dcdc_lnk430F6638.xcl
  XLINK.XlinkStackSize: 1
configuration eZ_FET_Debug (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  ICC430.CCDefines: eZ_FET
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetDcdc
  XLINK.XclFile: config\Dcdc_lnk430F5528.xcl
  group (top)
    src/dcdc/: cstartup_dcdc.s43
  group config
    config/: Dcdc_lnk430F5528.xcl Dcdc_lnk430F6638.xcl
  group DCDC
    src/dcdc/: FetDcdc.c
