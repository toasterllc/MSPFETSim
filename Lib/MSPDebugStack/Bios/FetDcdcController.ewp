# IAR project FetDcdcController.ewp, settings and files
configuration eZ_FET_Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EZ_FET; EZ_FET_V14
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetDcdcController
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2452.xcl
  XLINK.XlinkStackSize: 1
configuration MSP_FET_Debug (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MSP_FET; MSP_FET_V12
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetDcdcController
configuration MSP_FET2x_Debug (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MSP_FET; MSP_FET_V2X
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetDcdcControllerV2x
configuration eZ_FETV2x_Debug (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: EZ_FET; EZ_FET_V2X
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetDcdcControllerV2x
  group (top)
    src/fw/fet/EnergyTrace_TSPA/: VCC_Current.c
