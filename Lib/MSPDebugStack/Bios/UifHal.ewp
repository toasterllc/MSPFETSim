# IAR project UifHal.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F1612 MSP430F1612
  General.GStackSize2: 0
  General.GHeapSize2: 768
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: uController_uif; ARCH_MSP432; HAL_STREAM; __ICC430__; MSP430_UIF
  ICC430.newCCIncludePaths: include; src\hil; src\hil\uifv1; src\fw; src\fw\uifv1; src\hal
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  A430.ADefines: U2
  postbuild: "tools\convertEzFetTxt.bat" "$PROJ_DIR$" UifHal
  XLINK.XclFile: config\hal_lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    src/fw/uifv1/: uifVersion.h
  group Config
    config/: hal_lnk430F1612.xcl
  group Hal
    src/fw/uifv1/: cstartup.s43 hal432.c HalGlobalVars.h HalGlobalVars432.c halMain432.c
    src/hil/: edt.c
    ./: 
  group Hal/MSP432
    src/hal/macros/: DisableDebugArm.c EnableDebugArm.c GetCpuIdArm.c GetJtagIdCodeArm.c HaltArm.c MemApTransactionArm.c ReadAllCpuRegsArm.c ResetArm.c RunArm.c ScanApArm.c SingleStepArm.c WaitForDebugHaltArm.c WriteAllCpuRegsArm.c
  group Hal/MSPGeneric
    src/hal/macros/: BitSequence.c Configure.c DummyHal430.c GetInterfaceMode.c GetInterfaceModeArm.c HilCommand.c StartJtag.c StopJtag.c
  group Hil
    src/hil/uifv1/: arch.h hil432.c hil_4w_432.c hilDelays.c hilGeneric.c
