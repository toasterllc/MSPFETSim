# IAR project FET_ComChannel.ewp, settings and files
configuration MSP_FET_Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP_FET
  ICC430.newCCIncludePaths: include; src\hil; src\dcdc; src\fw\fet\USB_config; src\fw\fet\; src\fw\uart\ComBase
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetComChannel
  XLINK.XclFile: config\ComChannel_Ink430F6638.xcl
  XLINK.XlinkStackSize: 1
configuration eZ_FET_Debug (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  ICC430.CCDefines: eZ_FET
  ICC430.CCOptLevel: 2
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetComChannel
  XLINK.XclFile: config\ComChannel_Ink430F5528.xcl
  group (top)
    src/uart/: cstartup_uart.s43 FetCom.h
  group ComChannel/Bsl
    src/uart/BSL/: FetBsl.c FetBslI2c.c
  group ComChannel/Bsl/I2C
    src/uart/BSL/I2C/: I2C.c I2C.h
  group ComChannel/ComBase
    src/uart/ComBase/: COM_Base.c
  group ComChannel/Uart
    src/uart/Uart/: FetUart.c
  group config
    config/: ComChannel_Ink430F5528.xcl ComChannel_Ink430F6638.xcl
